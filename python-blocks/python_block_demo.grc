options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: python_block_demo
    output_language: python
    title: Python block demo
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 433.9e6
  states: {}
- name: integration_seconds
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: integrations
  id: variable
  parameters:
    value: int(np.round(samp_rate / nfft * integration_seconds))
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    label: Threshold
    type: real
    value: '5.0'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: integrations
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: nfft
    type: float
  states: {}
- name: blocks_integrate_xx_1_0
  id: blocks_integrate_xx
  parameters:
    decim: nfft
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: blocks_repeat_1_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      NFFT = 4096


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold=10.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Remove RFI',   # will show up in GRC
                  in_sig=[(np.float32, NFFT)],
                  out_sig=[(np.float32, NFFT)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]
              for out in output_items[0]:
                  median = np.median(out)
                  out[out > self.threshold * median] = 0.0
              return len(output_items[0])
    threshold: threshold
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackman(nfft)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 10 * round(samp_rate / (nfft * integrations))
    srate: samp_rate / (nfft * integrations)
    type: float
    ymax: '60'
    ymin: '40'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: nfft
    x_start: '-samp_rate / 2'
    x_step: samp_rate / nfft
    ymax: '60'
    ymin: '0'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: frequency
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_integrate_xx_0, '0', epy_block_0, '0']
- [blocks_integrate_xx_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_integrate_xx_1_0, '0', blocks_nlog10_ff_0_1_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_repeat_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_repeat_1, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_repeat_1_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_repeat_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_repeat_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_1, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_integrate_xx_1_0, '0']
- [epy_block_0, '0', blocks_nlog10_ff_0_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
